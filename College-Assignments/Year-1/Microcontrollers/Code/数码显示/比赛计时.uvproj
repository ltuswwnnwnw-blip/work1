# Keil uVision project 比赛计时.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5132 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) CLOCK(24000000) MODP2
  output: 比赛计时 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 比赛.c
